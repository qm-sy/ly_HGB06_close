# Keil uVision project 温控程序.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 温控闭环板modebuf程序 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\INC;..\温控程序-三路温控-modebus;..\温控程序-四路闭环温控-modebus
  group 源代码组 1
    ./: STARTUP.A51 温控程序.C modbus.c crc.c
